# Keil uVision project Project.uvprojx, settings and files
target Flash_Version (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MODE
  c include: .\Code\User;.\Code\BSP;.\Code\Cortex_M3;.\Code\STM32F10X;.\Code\Templete
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./Code/User/: user.c
  group STM32F10x
    ./Code/STM32F10X/: stm32f10xxx.h stm32f10x_rcc.c
  group Cortex-M3
    ./Code/Cortex_M3/: cortex_m3.h
  group Startup
    ./Code/Startup/: startup_stm32f10x_hd.s
  group Readme
    ./Readme/: readme.md
target SRAM_Version (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SRAM_MODE
  c include: as above
  memory RVCT4: ROM 0x2000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\hex_sram.sct
