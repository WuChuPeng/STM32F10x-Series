# Keil uVision project MDK.uvprojx, settings and files
target STM32F103ZE_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Package/User/: main.c main.h
  group Startup
    ../Package/Startup/: startup_stm32f10x_hd.s
  group CortexM3
    ../Package/Cortex_M3/: cortex_m3.h
    ../Package/Cortex_M3/cortex_systick/: cortex_systick.c
  group STM32F10x
    ../Package/STM32F10x/: stm32f10x.h
    ../Package/STM32F10x/stm32f10x_rcc/: stm32f10x_rcc.c
    ../Package/STM32F10x/stm32f10x_gpio/: stm32f10x_gpio.c
    ../Package/STM32F10x/stm32f10x_usart/: stm32f10x_usart.c
  group Peripheral
    ../Package/Peripheral/bsp_led/: bsp_led.c
    ../Package/Peripheral/bsp_beep/: bsp_beep.c
    ../Package/Peripheral/bsp_key/: bsp_key.c
target STM32F103ZE_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x2000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x10000
  scatter file: .\Objects\hex_sram.sct
